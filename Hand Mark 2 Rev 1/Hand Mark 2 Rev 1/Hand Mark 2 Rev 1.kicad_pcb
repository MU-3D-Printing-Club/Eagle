# Repository MU-3D-Printing-Club/Eagle

## KiCad design Hand Mark 2 Rev 1/Hand Mark 2 Rev 1/Hand Mark 2 Rev 1.kicad_pcb

Parts:
BT1: Battery_Cell; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
BTN1: Side_Button; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
C1, C3: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C5: 4.7uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4: 4.7uF 10V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6: 22uF 10V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CHRG1: MCP73831-2-OT; SOT-23-5
J1: Conn_ARM_JTAG_SWD_10; PinHeader_2x05_P1.27mm_Vertical
L1: 1uH 3A; L_1210_3225Metric_Pad1.42x2.65mm_HandSolder
LED1: Charging_LED; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
LED2: Charge_Done_LED; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
M1: Index_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
M2: Middle_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
M3: Ring_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
M4: Pinky_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
M5: Thumb_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
MCU1: ATSAMD11C14A-SS; SOIC-14_3.9x8.7mm_P1.27mm
MYO1: MyoWare; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
NEO1: Indicator_NeoPixel; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
R1: 2000ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R3: 470ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4: 1Mohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5, R8: 5000ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6, R9: 1250ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R7: 500ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
REG1: MIC5504-3.3YM5; SOT-23-5
REG2: MIC2876-5.5YMT-TR; DFN-8-1EP_2x2mm_P0.5mm_EP0.9x1.3mm
SW1: Power_Switch; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
USB1: USB_B_Micro; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal

Connections:
+3V3: C3.1, J1.1 (VTref), MCU1.12 (VDD), MYO1.1, NEO1.3 (VDD), REG1.5 (VOUT)
+5V: C6.1, M1.2 (+), M2.2 (+), M3.2 (+), M4.2 (+), M5.2 (+), REG2.5, REG2.8
+BATT: C1.1, C4.1, L1.2, R4.1, R5.1, REG1.1 (VIN), REG2.3, SW1.2 (B)
BTN: BTN1.1, MCU1.2 (PA08/XIN)
GND: BT1.2 (-), BTN1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.3 (GND), J1.5 (GND), J1.9 (GNDDetect), LED2.1 (K), M1.3 (-), M2.3 (-), M3.3 (-), M4.3 (-), M5.3 (-), MCU1.11 (GND), MYO1.2, NEO1.2 (GND), R6.2, R9.2, REG1.2 (GND), REG2.2, REG2.4, REG2.9, USB1.5 (GND), USB1.6 (Shield)
INDEX: M1.1 (PWM), MCU1.4 (PA14)
MIDDLE: M2.1 (PWM), MCU1.5 (PA15)
MYOSIG: MYO1.3, R8.1
NEO: MCU1.3 (PA09/XOUT), R7.2
NORMMYOSIG: MCU1.13 (PA02), R8.2, R9.1
NORMVBAT: MCU1.1 (PA05), R5.2, R6.1
unnamed: BT1.1 (+), C5.1, CHRG1.3 (VBAT), SW1.1 (A)
unnamed: C2.1, CHRG1.4 (VDD), LED1.2 (A), USB1.1 (VBUS)
unnamed: CHRG1.1 (STAT), R2.1, R3.1
unnamed: CHRG1.2 (VSS), R1.2
unnamed: CHRG1.5 (PROG), R1.1
unnamed: J1.2 (SWDIO/TMS), MCU1.8 (PA31/SWDIO)
unnamed: J1.4 (SWDCLK/TCK), MCU1.7 (PA30/SWCLK)
unnamed: J1.10 (~RESET~), MCU1.6 (PA28/~RST)
unnamed: L1.1, REG2.1
unnamed: LED1.1 (K), R2.2
unnamed: LED2.2 (A), R3.2
unnamed: NEO1.4 (DIN), R7.1
unnamed: R4.2, REG2.7
PINKY: M4.1 (PWM), MCU1.10 (PA25)
RING: M3.1 (PWM), MCU1.9 (PA24)
THUMB: M5.1 (PWM), MCU1.14 (PA04)

Board: 2 copper layers, 39.0 x 58.0 mm, 34 parts (6 on the bottom side), 27 nets.

## Commit log

2019-11-20 added biggnd and bigpower for large traces
2019-11-21 more ajustments
2019-11-21 refined board and fixed locations and orintations
2019-11-21 final refinement
2019-11-21 changed some pins to match arduino pins
2020-01-09 updated
    rotated servo ports
    removed unnecessary USB things
    moved some things around
2020-01-09 Error checking
2020-01-09 deleted old things
2020-01-09 Passes Oshpark DRU
2020-01-16 started on v2 board in kicad
2020-01-16 changed 3.3 regulator and added resistor to neopixel data input
2020-01-17 charger and 5v regulator added. should be ready for breadboard prototyping.
2020-01-18 starting pcb layout done
2020-01-19 moved parts to put logic on bottom of board
2020-01-19 finsihed first test routing(need thicker traces for power)
2020-01-20 added bigger traces to servo power but should be double checked
2020-01-21 added tx/rx and moved a few things
2020-01-21 shifted parts to give isp more room
2020-01-22 flipped ireg
2020-01-22 passed drc
2020-01-25 file rename
